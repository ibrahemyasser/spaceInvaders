# Keil uVision project SpaceInvaders.uvproj, settings and files
target SpaceInvaders (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: .\APP;.\HAL\inc;.\HAL\src;.\LIBRARIES\Common;.\LIBRARIES\CpuDriver\inc;.\LIBRARIES\CpuDriver\src;.\MCAL\DIO\inc;.\MCAL\DIO\Src;.\MCAL\INTERRUPT\Inc;.\MCAL\INTERRUPT\Src;.\MCAL\PORT\Inc;.\MCAL\PORT\Src;.\MCAL\SYSTICK\Inc;.\MCAL\SYSTICK\Src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Nokia5110.c random.s TExaS.c
    E:/3th CSE/Second term/Lab-Tiva-C/Lab4_IO/: config.h
  group APP
    ./APP/: main.c
  group HAL
    ./HAL/inc/: spaceInvaders.h
    ./HAL/src/: spaceInvaders.c spaceInvaders_Lcfg.c ISRs.c
  group MCAL
    ./MCAL/DIO/inc/: Dio.h Dio_Types.h
    ./MCAL/DIO/Src/: Dio.c
    ./MCAL/INTERRUPT/Inc/: IntCtrl.h IntCtrl_Cfg.h IntCtrl_Types.h
    ./MCAL/INTERRUPT/Src/: IntCtrl.c IntCtrl_Lcfg.c
    ./MCAL/PORT/Inc/: Port_Cfg.h
    ./MCAL/PORT/Src/: Port.c Port_Lcfg.c
    ./MCAL/SYSTICK/Inc/: Systick.h Systick_Types.h
    ./MCAL/SYSTICK/Src/: Systick.c
  group LIBRARIES
    ./LIBRARIES/Common/: Bit_Math.h Compiler.h Platform_Types.h Std_Types.h
    ./LIBRARIES/CpuDriver/inc/: cpu_driver.h
    ./LIBRARIES/CpuDriver/src/: cpu_driver.c
    E:/3th CSE/Second term/Lab-Tiva-C/Space invaders/LIBRARIES/Common/: Mcu_Hw.h
